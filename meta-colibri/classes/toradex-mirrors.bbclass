PREMIRRORS_append () {
cvs://.*/.*     http://sources.toradex.com/V2.5/
svn://.*/.*     http://sources.toradex.com/V2.5/
git://.*/.*     http://sources.toradex.com/V2.5/
gitsm://.*/.*   http://sources.toradex.com/V2.5/
hg://.*/.*      http://sources.toradex.com/V2.5/
bzr://.*/.*     http://sources.toradex.com/V2.5/
svk://.*/.*     http://sources.toradex.com/V2.5/
p4://.*/.*      http://sources.toradex.com/V2.5/
osc://.*/.*     http://sources.toradex.com/V2.5/
https?$://.*/.* http://sources.toradex.com/V2.5/
ftp://.*/.*     http://sources.toradex.com/V2.5/
}

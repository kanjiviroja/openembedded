PACKAGECONFIG_append_tegra = " \
    gstreamer010 \
"
PACKAGECONFIG_remove_tegra = " \
    gstreamer \
"
PACKAGE_ARCH_tegra = "${MACHINE_ARCH}"

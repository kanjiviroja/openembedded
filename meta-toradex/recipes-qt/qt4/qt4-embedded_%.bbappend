FILESEXTRAPATHS_prepend := "${THISDIR}/qt4:"

QT_CONFIG_FLAGS += " -depths all"

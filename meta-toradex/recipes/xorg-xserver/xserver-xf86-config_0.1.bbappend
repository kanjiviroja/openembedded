FILESEXTRAPATHS_prepend := "${THISDIR}/xserver-xf86-config:"

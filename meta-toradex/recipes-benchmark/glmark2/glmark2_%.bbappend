#build it only for OpenGL ES
PACKAGECONFIG_tegra = "gles2"
PACKAGES_DYNAMIC = "${PN}-*"

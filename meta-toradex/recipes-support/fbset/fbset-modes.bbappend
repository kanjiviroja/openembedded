# Provide fb-modes file for vybrid
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
#don't install the perl scripts provided in i2c-tools-misc (and thus don't RDEPEND on perl)
RDEPENDS_${PN} = ""

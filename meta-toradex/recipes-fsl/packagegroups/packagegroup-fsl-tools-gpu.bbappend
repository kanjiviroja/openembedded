# don't include the rather large examples and apitrace tool
SOC_TOOLS_GPU_remove_mx6 = " \
    fsl-gpu-sdk \
    imx-gpu-viv-tools-apitrace \
"

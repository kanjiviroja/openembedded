#lib/sysquotas_nfs.c:41:27: fatal error: rpcsvc/rquota.h: No such file or directory
# #include <rpcsvc/rquota.h>
DEPENDS += "quota"

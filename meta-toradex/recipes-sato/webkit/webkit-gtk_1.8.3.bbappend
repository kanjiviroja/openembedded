EXTRA_OECONF_append_vf = "\
 --enable-video=no --enable-video-track=no --enable-web-audio=no \
 --enable-webgl=no --enable-spellcheck=no  \
"
PACKAGE_ARCH_vf = "${MACHINE_ARCH}"

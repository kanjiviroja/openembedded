#do not build with smb/samba
PACKAGECONFIG = ""
DEPENDS += "udev"

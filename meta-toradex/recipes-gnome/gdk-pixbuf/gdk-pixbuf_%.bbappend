# build for x11, at least lxpanel needs this
PACKAGECONFIG_append = " x11"

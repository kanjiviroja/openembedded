FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://fix_garbled_titlebar.patch \
"

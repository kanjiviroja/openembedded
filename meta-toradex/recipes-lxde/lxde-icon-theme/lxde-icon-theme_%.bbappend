#remove the gnome icon theme package
RDEPENDS = ""
